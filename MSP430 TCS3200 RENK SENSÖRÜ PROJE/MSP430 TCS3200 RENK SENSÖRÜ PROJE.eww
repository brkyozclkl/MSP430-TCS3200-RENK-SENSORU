<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSP430 TCS3200 RENK SENSÖRÜ PROJE.ewp</path>
    </project>
    <batchBuild />
</workspace>
